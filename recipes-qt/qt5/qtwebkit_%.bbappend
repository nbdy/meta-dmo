EXTRA_OECONF += "widgets"

