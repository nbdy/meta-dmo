LIC_FILES_CHKSUM = "file://LICENSE.GPL;md5=05832301944453ec79e40ba3c3cfceec \
                    file://LICENSE.LGPLv3;md5=e6a600fd5e1d9cbde2d983680233ad02 \
"
