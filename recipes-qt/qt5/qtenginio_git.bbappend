FILESEXTRAPATHS_prepend := "${THISDIR}/qtenginio:"

SRC_URI += "file://0021-Rename-QUrl-enum-value-from-None-to-Nothing.patch"
