inherit dmo-launcher-app

DMO_LAUNCHER = "emitters"

DMO_LAUNCHER_EXEC[emitters] = "/usr/share/qt5/examples/quick/particles/emitters/emitters"
DMO_LAUNCHER_NAME[emitters] = "Emitters"
DMO_LAUNCHER_DESC[emitters] = "Emitters qt5 demo"
DMO_LAUNCHER_ICONPATH[emitters] = "/usr/share/qt5/examples/quick/particles/images/starfish_2.png"
