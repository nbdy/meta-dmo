require qt5-dmo.inc

