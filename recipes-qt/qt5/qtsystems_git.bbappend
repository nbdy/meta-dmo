
# qtsystems.git changes the branchnames like changes the underwaer
QT_MODULE_BRANCH = "dev"

