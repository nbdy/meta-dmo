MIRRORS_append = "\
ftp://.*/.*     ftp://ftp.samba.org/pub/samba/stable/  \n \
http://.*/.*    ftp://ftp.samba.org/pub/samba/stable/  \n \
https://.*/.*   ftp://ftp.samba.org/pub/samba/stable/  \n"

