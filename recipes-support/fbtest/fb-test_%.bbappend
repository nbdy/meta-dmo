do_install_append() {
    mv ${D}${bindir}/offset ${D}${bindir}/offset.fb-test
}
