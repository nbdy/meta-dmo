
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://libcanberra-for-gstreamer-0.11.patch"
