MIRRORS += "git://.*/.*     git://gitorious.org/xfce/xfce4-settings.git;protocol=http  \n "

