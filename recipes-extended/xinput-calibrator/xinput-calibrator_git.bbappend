
# override RRECOMMENDS for this package...
RRECOMMENDS_${PN} = ""
