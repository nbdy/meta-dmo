
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://wget-1.14-perl-5.18-pod-fixes.diff"
