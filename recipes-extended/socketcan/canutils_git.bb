require recipes-extended/socketcan/canutils_4.0.6.bb

SRCREV = "${AUTOREV}"
SRC_URI = "git://git.pengutronix.de/git/tools/canutils.git;protocol=git;branch=master "

