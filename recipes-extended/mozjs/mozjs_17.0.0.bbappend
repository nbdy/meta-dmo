
EXTRA_OECONF += " \
    --without-x \
"

