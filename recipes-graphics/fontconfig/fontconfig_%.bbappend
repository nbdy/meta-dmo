FILESEXTRAPATHS_append := "${THISDIR}/patches:"
SRC_URI += "file://fix-pkg-config-compile-flags.patch"
