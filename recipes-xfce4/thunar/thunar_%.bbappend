inherit dmo-launcher-app

DMO_LAUNCHER_EXEC = "/usr/bin/thunar"
DMO_LAUNCHER_NAME = "thunar"
DMO_LAUNCHER_DESC = "File Browser"
DMO_LAUNCHER_ICONPATH = "/usr/share/icons/hicolor/128x128/apps/Thunar.png"

