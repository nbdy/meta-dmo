include cpu-status-info.inc

PR = "${INC_PR}.1"

SRC_URI = " \
    ${DMOFTP}/${PN}-${PV}.tar.gz \
"
SRC_URI[md5sum] = "20ecd4ea06e5de6ad844bd31517daeab"
SRC_URI[sha256sum] = "cb7b60cd763bcaf79fc3be0f7458eddda9c0fbd5345fd7d73dc38cca7150cf6f"
