
SRC_URI = "git://git.denx.de/mxsldr.git;protocol=http"

