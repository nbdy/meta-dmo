
DEPENDS_append = " libgnome-keyring "
